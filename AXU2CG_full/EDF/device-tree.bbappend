
FILESEXTRAPATHS:prepend := "${THISDIR}/files:"
EXTRA_DT_INCLUDE_FILES:append:amd-cortexa53-mali-common:linux = " system-user.dtsi"

