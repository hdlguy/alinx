KERNEL_CMDLINE_EXTRA:append = " rw clk_ignore_unused"

